<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\program\MM32F3277.ewp</path>
    </project>
    <batchBuild />
</workspace>
